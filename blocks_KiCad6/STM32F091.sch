File: blocks_KiCad6/STM32F091.sch (KiCad schematic (older format))
At the start: 11 parts

Commit message: redcube footprints modified
Connections:
- net ~reset renamed ~{reset}
